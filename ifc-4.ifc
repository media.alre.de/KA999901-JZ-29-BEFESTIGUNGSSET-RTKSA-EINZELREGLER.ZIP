Properties of the parts of a building model (IFC4)

# File
Description: Befestigungsset RTKSA THK/NTHK/SWK Einzelregler, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA999901, Befestigungsset RTKSA THK/NTHK/SWK Einzelregler
In: Raum
Description: Befestigungsset RTKSA für THK/NTHK/SWK Einzelregler in Verbindung mit Tauchhülsen THK/NTHK und Schutzwendel SWK; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA999901; ModelLabel: JZ-29; GlobalTradeItemNumber: 4050528075505; ProductURL: https://alre.de/produkt_KA999901
Pset_Specification - NominalLength: 0.09 m; NominalWidth: 0.007 m; NominalDepth: 0.001 m; NetWeight: 0.004
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 7; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA999901.pdf
